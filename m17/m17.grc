options:
  parameters:
    generate_options: no_gui
    id: m17
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: audio_rate // 4800
  states: {}
- name: m17_deviation
  id: variable
  parameters:
    value: '800'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '8700000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '28800000'
  states: {}
- name: amplitude
  id: parameter
  parameters:
    type: eng_float
    value: '0.8'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: m17_deviation * 2 * math.pi / audio_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: offset * (2 * math.pi / samp_rate)
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Clayton Smith
    center_freq: np.nan
    filename: out_file
    sample_rate: samp_rate
    type: complex float (fc32_le)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[+1.0,+3.0,-1.0,-3.0]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: in_file
  id: parameter
  parameters:
    type: str
    value: foo.bin
  states: {}
- name: out_file
  id: parameter
  parameters:
    type: str
    value: bar
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // audio_rate
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: interpolation_rate
    interp: interpolation_rate
    ntaps: interpolation_rate*11+1
    samp_rate: interpolation_rate
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_rotator_cc_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_rotator_cc_0, '0']
- [root_raised_cosine_filter_0_0, '0', analog_frequency_modulator_fc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
