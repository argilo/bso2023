options:
  parameters:
    author: argilo
    generate_options: no_gui
    id: transmit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '28800000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: out.sc16
    repeat: 'True'
    type: short
    vlen: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '24000000'
    center_freq0: freq
    dev_addr: '"send_frame_size=8192,num_send_frames=256"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: sc16
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
