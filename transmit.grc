options:
  parameters:
    author: argilo
    generate_options: qt_gui
    id: transmit
    output_language: python
    title: BSides 2023 Main
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: i_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    start: '-0.1'
    step: '0.0005'
    stop: '0.1'
    value: '0.007'
  states: {}
- name: mag
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 0, 1, 1
    start: '-0.2'
    step: '0.001'
    stop: '0.2'
    value: '0.035'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 0, 1, 1
    start: '-0.2'
    step: '0.001'
    stop: '0.2'
    value: '0.066'
  states: {}
- name: power
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    start: '17'
    step: '1.0'
    stop: '73'
    value: '43'
  states: {}
- name: q_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 1
    start: '-0.1'
    step: '0.0005'
    stop: '0.1'
    value: '0.001'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '28800000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: i_off + q_off * 1j
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: out.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: iqbalance_fix_cc_0
  id: iqbalance_fix_cc
  parameters:
    mag: mag
    phase: phase
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '26000000'
    center_freq: freq
    gain: power
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '24000000'
    center_freq0: freq
    dev_addr: '"send_frame_size=8192,num_send_frames=256"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_add_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_file_source_0, '0', iqbalance_fix_cc_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [iqbalance_fix_cc_0, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
