options:
  parameters:
    generate_options: no_gui
    id: extract_fm
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: interp
  id: variable
  parameters:
    value: '120'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '16000'
    gain: '2.0'
    samp_rate: samp_rate
    width: '8000'
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: '-9800000'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: samp_rate * interp
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32768.0'
    vector_output: 'False'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * offset / out_rate
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Clayton Smith
    center_freq: np.nan
    filename: dtmf
    sample_rate: out_rate
    type: complex short (sc16_le)
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: gqrx_20231021_192828_441000000_240000_fc.sigmf-data
    repeat: 'False'
    type: complex float (fc32_le)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '25600'
    decim: '1'
    samp_rate: samp_rate
    taps: lp_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interp
    type: ccc
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_rotator_cc_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_sigmf_source_minimal_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
